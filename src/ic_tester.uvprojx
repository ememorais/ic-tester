# Keil uVision project ic_tester.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: exemplo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ../fonts/: font_default.c
    ./: startup.s utils.s main.c tm4c1294ncpdt.h keyboard.s utils.h keyboard.h timer.c timer.h globals.h gpio.c gpio.h i2c.c ic_tester.c
    ../images/: 74LS32.c 74LS00.c 74LS08.c utfpr_bar.c loading_empty.c 74LSXX.c
